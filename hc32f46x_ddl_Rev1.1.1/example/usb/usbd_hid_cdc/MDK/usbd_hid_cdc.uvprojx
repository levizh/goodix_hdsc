# Keil uVision project usbd_hid_cdc.uvprojx, settings and files
target usbd_hid_cdc_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usbd_hid_cdc
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;;..\..\..\..\usb_lib\device_core;..\..\..\..\usb_lib\device_class\cdc_vcp;..\..\..\..\usb_lib\device_class\hid_custom;..\..\..\..\usb_lib\device_class\hid_cdc_wrapper;..\..\..\..\usb_lib\ctl_drv
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f46x.s
    ../../../../mcu/common/: system_hc32f46x.c
  group source
    ../source/: main.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c usb_bsp_template.c
  group driver
    ../../../../driver/src/: hc32f46x_icg.c hc32f46x_utility.c hc32f46x_clk.c hc32f46x_efm.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_pwc.c hc32f46x_usart.c
  group device_core
    ../../../../usb_lib/device_core/: usbd_core.c usbd_ioreq.c usbd_req.c
  group device_class
    ../../../../usb_lib/device_class/cdc_vcp/: usbd_cdc_vcp_core.c
    ../../../../usb_lib/device_class/hid_custom/: usbd_hid_custom_core.c
    ../../../../usb_lib/device_class/hid_cdc_wrapper/: usbd_hid_cdc_wrapper.c
  group ctl_drv
    ../../../../usb_lib/ctl_drv/: usb_core.c usb_otg.c usb_dcd.c usb_dcd_int.c
target usbd_hid_cdc_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.0
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usbd_hid_cdc +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 4.1.0
