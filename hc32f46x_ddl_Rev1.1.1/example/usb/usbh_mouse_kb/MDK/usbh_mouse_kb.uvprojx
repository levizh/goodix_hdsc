# Keil uVision project usbh_mouse_kb.uvprojx, settings and files
target usbh_mouse_kb_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usbh_mouse_kb
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;;..\..\..\..\usb_lib\host_core;..\..\..\..\usb_lib\host_class\hid;..\..\..\..\usb_lib\ctl_drv
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f46x.s
    ../../../../mcu/common/: system_hc32f46x.c
  group source
    ../source/: main.c usbh_usr.c usbh_usr_print.c usb_bsp_template.c
  group driver
    ../../../../driver/src/: hc32f46x_icg.c hc32f46x_utility.c hc32f46x_clk.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_pwc.c
  group host_core
    ../../../../usb_lib/host_core/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group host_class
    ../../../../usb_lib/host_class/hid/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c
  group ctl_drv
    ../../../../usb_lib/ctl_drv/: usb_core.c usb_otg.c usb_hcd.c usb_hcd_int.c
target usbh_mouse_kb_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.0
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usbh_mouse_kb +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 4.1.0
